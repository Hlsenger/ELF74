# IAR project Lab5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; TX_ENABLE_IAR_LIBRARY_SUPPORT; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCIncludePath2: ThirdParty\Threadx\inc; ThirdParty\TivaWare_C_Series-2.2.0.295\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab5.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group Libraries
    ThirdParty/TivaWare_C_Series-2.2.0.295/libs/: driverlib.a
    ThirdParty/Threadx/lib/: tx.a
  group Source
    src/: cstartup_M.s lab5.c tx_initialize_low_level.s
