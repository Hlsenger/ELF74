# IAR project TrabalhoFinal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1292NCPDT TexasInstruments TM4C1292NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; TX_ENABLE_IAR_LIBRARY_SUPPORT; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCIncludePath2: ThirdParty\Threadx\inc; ThirdParty\TivaWare_C_Series-2.2.0.295\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries
    ThirdParty/TivaWare_C_Series-2.2.0.295/libs/: driverlib.a
    ThirdParty/Threadx/lib/: tx.a
  group Source
    src/: charbuffer.c charbuffer.h cstartup_M.s defines.h elevador.c elevador.h main.c tx_initialize_low_level.s
