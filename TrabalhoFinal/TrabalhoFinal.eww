<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TrabalhoFinal.ewp</path>
    </project>
    <batchBuild />
</workspace>
